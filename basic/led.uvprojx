# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xD400) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\start;.\libraries;.\system;.\hardware
  memory RVCT4: ROM 0x8000000 size 0xd400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c config.h
  group start
    ./start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group libraries
    ./libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group system
    ./system/: Delay.c Delay.h
  group hareware
    ./hardware/: OLED.c OLED.h OLED_Font.h flash.c flash.h AS608.c AS608.h key.c key.h led.c led.h encoder.c encoder.h motor.c motor.h buzzer.c buzzer.h store.c store.h log.c log.h
  group Pattern Lock
    ./hardware/: pattern.c pattern.h pattern_store.c pattern_store.h pattern_view.c pattern_view.h
  group Pattern Application
    ./user/: pattern_app.c pattern_app.h
  group Timebase
    ./system/: timebase.c timebase.h
  group Password Input Test
    ./user/: password_demo.c password_demo.h
  group Dial Test
    ./hardware/: dial_sequence.c dial_sequence.h dial_view.c dial_view.h
  group Interaction Test Menu
    ./user/: interaction_demo.c interaction_demo.h
  group Password Input Core
    ./hardware/: password_input.c password_input.h
  group Input Events
    ./hardware/: input_event.c input_event.h
  group Duress Preparation
    ./hardware/: credentials.c credentials.h auth.c auth.h credential_store.c credential_store.h
    ./user/: duress_demo.c duress_demo.h
  group Audit Log Preparation
    ./hardware/: audit.c audit.h
    ./user/: log_demo.c log_demo.h
  group Administrator Core
    ./hardware/: admin_store.c admin_store.h admin_fingerprint.c admin_fingerprint.h credential_editor.c credential_editor.h
